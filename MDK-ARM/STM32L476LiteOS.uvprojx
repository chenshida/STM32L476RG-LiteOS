# Keil uVision project STM32L476LiteOS.uvprojx, settings and files
target STM32L476LiteOS (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.0.0
  cpu: IRAM(0x20000000-0x20017FFF) IRAM2(0x10000000-0x10007FFF) IROM(0x8000000-0x80FFFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: STM32L476LiteOS +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L476xx
  c include: ../Inc;../Drivers/STM32L4xx_HAL_Driver/Inc;../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../Drivers/CMSIS/Include;../MiddleWares/LiteOS/arch/arm/arm-m/include;../MiddleWares/LiteOS/OS_CONFIG;../MiddleWares/LiteOS/kernel/include;../MiddleWares/LiteOS/kernel/base/include;../MiddleWares/LiteOS/kernel/extended/include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  group Application/MDK-ARM
    ./: startup_stm32l476xx.s
  group Application/User
    ../Src/: main.c gpio.c usart.c stm32l4xx_it.c stm32l4xx_hal_msp.c
  group Drivers/STM32L4xx_HAL_Driver
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_cortex.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Middleware/LiteOS/arch
    ../MiddleWares/LiteOS/arch/arm/arm-m/src/: los_hw.c los_hw_tick.c los_hwi.c
    ../MiddleWares/LiteOS/arch/arm/arm-m/cortex-m4/keil/: los_dispatch_keil.S
  group Middleware/lLiteOS/Kernel
    ../MiddleWares/LiteOS/kernel/: los_init.c
    ../MiddleWares/LiteOS/kernel/base/core/: los_priqueue.c los_swtmr.c los_sys.c los_task.c los_tick.c los_timeslice.c
    ../MiddleWares/LiteOS/kernel/base/ipc/: los_event.c los_mux.c los_queue.c los_sem.c
    ../MiddleWares/LiteOS/kernel/base/misc/: los_misc.c
    ../MiddleWares/LiteOS/kernel/base/om/: los_err.c
    ../MiddleWares/LiteOS/kernel/base/mem/bestfit_little/: los_heap.c los_memory.c
    ../MiddleWares/LiteOS/kernel/base/mem/common/: los_memcheck.c los_memstat.c los_slab.c los_slabmem.c
    ../MiddleWares/LiteOS/kernel/base/mem/membox/: los_membox.c
    ../MiddleWares/LiteOS/kernel/extended/tickless/: los_tickless.c
software components: CMSIS:CORE 4.3.0
